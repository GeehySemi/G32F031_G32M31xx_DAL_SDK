<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FLASH_Read_Write.ewp</path>
    </project>
    <batchBuild />
</workspace>
