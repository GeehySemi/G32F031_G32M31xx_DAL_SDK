# Keil uVision project CMSIS_FreeRTOS.uvprojx, settings and files
target G32F031 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: G32F031K8 Geehy
  pack: Geehy.G32F031_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMSIS_FreeRTOS
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_FULL_DDL_DRIVER, G32F031xx,BOARD_G32F031_EVB
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\G32F031_DAL_Driver\Include;..\..\..\..\..\..\Libraries\Device\Geehy\G32F031\Include;..\..\..\..\..\..\Boards\Board_G32F031_EVB\Include;..\..\Config\Include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\CMSIS\RTOS2\FreeRTOS\Include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_g32f031.c
    ./: startup_g32f031.s
  group G32F031_DDL_Driver
    ../../../../../../Libraries/G32F031_DAL_Driver/Source/: g32f031_ddl_adc.c g32f031_ddl_atmr.c g32f031_ddl_btmr.c g32f031_ddl_comp0.c g32f031_ddl_comp1.c g32f031_ddl_crc.c g32f031_ddl_div.c g32f031_ddl_dma.c g32f031_ddl_eint.c g32f031_ddl_flash.c g32f031_ddl_gpio.c g32f031_ddl_gtmr.c g32f031_ddl_i2c.c g32f031_ddl_lptmr.c g32f031_ddl_opa.c g32f031_ddl_rcc.c g32f031_ddl_spi.c g32f031_ddl_usart.c g32f031_ddl_utils.c
  group Board
    ../../../../../../Boards/Board_G32F031_EVB/Source/: board_g32f031_evb_ddl.c
  group Config
    ../../Config/Source/: g32f031_device_cfg.c g32f031_usart_cfg.c
  group Application
    ../../Source/: main.c g32f031_int.c
  group Middlewares/CMSIS-FreeRTOS
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c os_systick.c
  group Middlewares/CMSIS-FreeRTOS/Portable
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Document
    ../../: readme.txt
