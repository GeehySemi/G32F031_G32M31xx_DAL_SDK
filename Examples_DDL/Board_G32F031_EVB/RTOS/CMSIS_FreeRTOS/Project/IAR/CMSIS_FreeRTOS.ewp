# IAR project CMSIS_FreeRTOS.ewp, settings and files
configuration G32F031 (ARM)
  General.OGChipSelectEditMenu: G32F031 Geehy G32F031x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_DDL_DRIVER; G32F031xx; BOARD_G32F031_EVB
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\G32F031_DAL_Driver\include; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\G32F031\Include; ..\..\Include; ..\..\Config\Include; ..\..\..\..\..\..\Boards\Board_G32F031_EVB\Include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\CMSIS\RTOS2\FreeRTOS\Include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Include
  OBJCOPY.OOCOutputFile: CMSIS_FreeRTOS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: g32f031_int.c main.c
  group Board
    ../../../../../../Boards/Board_G32F031_EVB/Source/: board_g32f031_evb_ddl.c
  group CMSIS
    ./: startup_g32f031.s
    ../../Source/: system_g32f031.c
  group Config
    ../../Config/Source/: g32f031_device_cfg.c g32f031_usart_cfg.c
  group Document
    ../../: readme.txt
  group G32F031_DDL_Driver
    ../../../../../../Libraries/G32F031_DAL_Driver/Source/: g32f031_ddl_adc.c g32f031_ddl_atmr.c g32f031_ddl_btmr.c g32f031_ddl_comp0.c g32f031_ddl_comp1.c g32f031_ddl_crc.c g32f031_ddl_div.c g32f031_ddl_dma.c g32f031_ddl_eint.c g32f031_ddl_flash.c g32f031_ddl_gpio.c g32f031_ddl_gtmr.c g32f031_ddl_i2c.c g32f031_ddl_lptmr.c g32f031_ddl_opa.c g32f031_ddl_rcc.c g32f031_ddl_spi.c g32f031_ddl_usart.c g32f031_ddl_utils.c
  group Middlewares/CMSIS-FreeRTOS
    ../../../../../../Middlewares/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c os_systick.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/CMSIS-FreeRTOS/Portable
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
